# Keil uVision project UIBoard.uvprojx, settings and files
target UIBoard (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B0VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x240FFFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: UIBoard +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H7B0xx
  c include: ../Core/Inc;../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../../../jiaye-drivers;../../../MY_STM_Common/Inc;../../shared;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include
  asm include: ../Core/Inc;../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  memory RVCT1: ROM 0x90000000 size 0x800000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x100000
  group Application/MDK-ARM
    ./: startup_stm32h7b0xx.s
  group Application/User/Core
    ../../../jiaye-drivers/: serial_protocol_echo.c
    ../../../MY_STM_Common/Src/: common.c my_math.c myTouchGFXUtilities.c
    ../Core/Src/: touch_800x480.c touch_iic.c wewalk_debug_gui_interface.c main.c freertos.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group gui
    ../touchgfx/gui/src/common/: customkeyboard.cpp frontendapplication.cpp
    ../touchgfx/gui/src/containers/: joystick_1_container.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/screen_menu_screen/: screen_menupresenter.cpp screen_menuview.cpp
    ../touchgfx/gui/src/screen_research_screen/: screen_researchpresenter.cpp screen_researchview.cpp
    ../touchgfx/gui/src/screen_settings_screen/: screen_settingspresenter.cpp screen_settingsview.cpp
    ../touchgfx/gui/src/screen_wewalkliveplot_screen/: screen_wewalkliveplotpresenter.cpp screen_wewalkliveplotview.cpp
    ../touchgfx/gui/src/screen_wewalkmanualcontrol_screen/: screen_wewalkmanualcontrolpresenter.cpp screen_wewalkmanualcontrolview.cpp
    ../touchgfx/gui/src/screen_wewalk_screen/: screen_wewalkpresenter.cpp screen_wewalkview.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp compressedfontcache.cpp compressedunmappedfontcache.cpp font_verdana_20_4bpp_0.cpp font_verdana_20_4bpp_4.cpp font_verdana_40_4bpp_0.cpp font_verdanab_15_4bpp_0.cpp font_verdanab_20_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_verdana_20_4bpp.cpp kerning_verdana_40_4bpp.cpp kerning_verdanab_15_4bpp.cpp kerning_verdanab_20_4bpp.cpp table_verdana_20_4bpp.cpp table_verdana_40_4bpp.cpp table_verdanab_15_4bpp.cpp table_verdanab_20_4bpp.cpp unmappeddatafont.cpp vectorfontrendererbuffers.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp image_icon_keyboard_even_row.cpp image_icon_keyboard_highlighted.cpp image_icon_keyboard_odd_row.cpp image_keyboard_background.cpp image_keyboard_key_delete_highlighted.cpp image_keyboard_key_highlighted.cpp image_keyboard_key_num_highlighted.cpp image_keyboard_key_shift_highlighted.cpp image_keyboard_space_highlighted.cpp image_menu_page_background.cpp image_the_wrong_trousers.cpp image_vernier_motor.cpp image_wewalk.cpp svgdatabase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/images/src/__generated/: image_alternate_theme_images_widgets_button_icon_rounded_tiny_outline_disabled.cpp image_alternate_theme_images_widgets_button_regular_height_50_large_round_active.cpp image_alternate_theme_images_widgets_button_regular_height_50_large_round_pressed.cpp image_alternate_theme_images_widgets_button_regular_height_50_medium_rounded_action.cpp image_alternate_theme_images_widgets_button_regular_height_50_medium_rounded_pressed.cpp image_alternate_theme_images_widgets_button_regular_height_50_small_rounded_action.cpp image_alternate_theme_images_widgets_button_regular_height_50_small_rounded_pressed.cpp image_alternate_theme_images_widgets_radiobutton_radio_medium_round_off.cpp image_alternate_theme_images_widgets_radiobutton_radio_medium_round_off_pressed.cpp image_alternate_theme_images_widgets_radiobutton_radio_medium_round_on_active.cpp image_alternate_theme_images_widgets_radiobutton_radio_medium_round_on_pressed.cpp image_alternate_theme_images_widgets_radiobutton_radio_medium_rounded_off.cpp image_alternate_theme_images_widgets_radiobutton_radio_medium_rounded_off_pressed.cpp image_alternate_theme_images_widgets_radiobutton_radio_medium_rounded_on_dark.cpp image_alternate_theme_images_widgets_radiobutton_radio_medium_rounded_on_pressed.cpp image_alternate_theme_images_widgets_swipecontainer_medium_off_normal.cpp image_alternate_theme_images_widgets_swipecontainer_medium_on_active.cpp image_clay_theme_images_widgets_button_regular_height_36_medium_round_normal.cpp image_clay_theme_images_widgets_button_regular_height_36_medium_round_pressed.cpp image_icon_theme_images_action_done_50_50_e8f6fb.svg.cpp image_icon_theme_images_action_home_filled_50_50_e8f6fb.svg.cpp image_icon_theme_images_hardware_keyboard_return_50_50_e8f6fb.svg.cpp
    ../touchgfx/generated/gui_generated/src/containers/: joystick_1_containerbase.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/screen_menu_screen/: screen_menuviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screen_research_screen/: screen_researchviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screen_settings_screen/: screen_settingsviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screen_wewalkliveplot_screen/: screen_wewalkliveplotviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screen_wewalkmanualcontrol_screen/: screen_wewalkmanualcontrolviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screen_wewalk_screen/: screen_wewalkviewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
software components: CMSIS:CORE 4.3.0
